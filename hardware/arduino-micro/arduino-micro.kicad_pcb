# Repository fardog/squeeze

File README.md:

# squeeze

A 3D Printer enclosure built from a wall-mount server rack. Includes:

* Exhaust fans: speed control hardware, adapters, filtration
* Filament paths: bowden tube rigging from a dry box to the enclosure
* Case parts: power supply mounts, case feet

## License

[MIT](./LICENSE)

## KiCad design hardware/arduino-micro/arduino-micro.kicad_pcb

Parts:
C1: 100uF; CP_EIA-7343-31_Kemet-D
C2: 0.1uF; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C3, C4: 100pF; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: PJ-083H; CUI_PJ-083H
J2: i2c_header; Molex_KK-254_AE-6410-04A_1x04_P2.54mm_Vertical
M1: Fan_4pin; Molex_KK-254_AE-6410-04A_1x04_P2.54mm_Vertical
R1, R2, R3, R4, R5, R7, R8, R9, R10: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R6: 27k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
SW1: Rotary_Encoder; RotaryEncoder_Alps_EC11E_Vertical_H20mm
U1: TM1637; SOIC-20W_7.5x12.8mm_P1.27mm
U2: CA56-12CGKWA
U3: BUTTON_1; PTS525_SM15_SMTR2_LFS
U4: BUTTON_2; PTS525_SM15_SMTR2_LFS
U5: BUTTON_3; PTS525_SM15_SMTR2_LFS
XA1: Arduino_Micro_Socket

Connections:
+12V: J1.1, M1.2 (+), R3.1, XA1.VIN; also elsewhere on the board
/5V: C1.1, C2.1, J2.2 (5V), R1.1, R2.1, R4.1, R5.1, U1.16 (VDD), U3.2, U4.2, U5.2, XA1.5V
/7S_CLK: C4.2, R5.2, U1.18 (CLK), XA1.SCK (SPI_SCK)
/7S_IO: C3.2, R4.2, U1.17 (DIO), XA1.MOSI (SPI_MOSI)
GND: C1.2, C2.2, C3.1, C4.1, J1.2, J1.3, J2.1 (GND), M1.1 (-), R7.1, R8.2, R9.2, R10.2, SW1.C, U1.1 (GND), XA1.GND1 (GND), XA1.GND2 (GND); also elsewhere on the board
unnamed: J1.S1, J1.S2
unnamed: J2.3 (SDA), XA1.D2 (D2_SDA)
unnamed: J2.4 (SCL), XA1.D3 (D3_SCL)
unnamed: M1.3 (Tacho), R3.2, R6.2
unnamed: M1.4 (PWM), XA1.D5
unnamed: R1.2, SW1.A, XA1.A1
unnamed: R2.2, SW1.B, XA1.A0
unnamed: R6.1, R7.2, XA1.D7 (D7_INT4)
unnamed: R8.1, U4.4, XA1.D12
unnamed: R9.1, U3.4, XA1.D11
unnamed: R10.1, U5.4, XA1.D13
unnamed: U1.2 (SG1/KS1), U2.11 (a)
unnamed: U1.3 (SG2/KS2), U2.7 (b)
unnamed: U1.4 (SG3/KS3), U2.4 (c)
unnamed: U1.5 (SG4/KS4), U2.2 (d)
unnamed: U1.6 (SG5/KS5), U2.1 (e)
unnamed: U1.7 (SG5/KS5), U2.10 (f)
unnamed: U1.8 (SG7/KS7), U2.5 (g)
unnamed: U1.9 (SG8/KS8), U2.3 (DPX)
unnamed: U1.12 (GRID4), U2.6 (CA4)
unnamed: U1.13 (GRID3), U2.8 (CA3)
unnamed: U1.14 (GRID2), U2.9 (CA2)
unnamed: U1.15 (GRID1), U2.12 (CA1)

Board: 2 copper layers, 78.0 x 47.0 mm, 26 parts (13 on the bottom side), 29 nets.

Other parts of the board:
R11: 14k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R12: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder

Their connections:
+12V: R11.2; also elsewhere on the board
GND: R12.2; also elsewhere on the board
unnamed: R11.1, R12.1

## Commit log

2018-10-21 initial firmware for arduino micro
2018-10-21 remove vscode dir
2018-10-21 platform.io adds these back
2018-10-21 init kicad; add arduino lib submodule
2018-10-21 change pin for tach
2018-10-22 cnc test pcbs
2018-10-23 fixes for cnc'd pcb
2018-10-23 add back missing libs
2018-10-23 more unignores
2018-10-24 fix too close edge
2018-10-25 cleanup
2018-10-27 begin work on case designs
2018-10-28 front grill
2018-10-28 split filter gage
2018-10-28 fixes; grill refactor. remove unnecessary insets
2018-10-28 reorg
2018-10-29 wip angled base
2018-10-29 make angled base parametric
2018-10-29 update stl and gcode
2018-10-29 fix gcode incorrectly laid flat
2018-10-29 fixes, stls, gcode
2018-10-30 wip duct adapter
2018-11-01 adapter fix prior to offset increase
2018-11-01 base offset
2018-11-01 comments, stl, gcode
2018-11-02 parameterize duct adapter
2018-11-02 parameterize triangle insets
2018-11-02 fix offset
2018-11-02 Duct adapter (#1)
    * wip duct adapter
    * adapter fix prior to offset increase
    * base offset
    * comments, stl, gcode
    * parameterize duct adapter
    * parameterize triangle insets
2018-11-02 fix upper adapter cylinder inset
2018-11-11 fix cone util
2018-11-11 fixes, filter cut
2018-11-15 filter caddy
2018-11-17 outside duct adapters, case feet
2018-11-17 gcode updates
2018-11-19 filament work, power supply bushings
2018-11-19 filament passthrough
2018-11-19 reorganize
2018-11-20 parametric passthrough
2018-11-20 separate passthrough files
2018-12-15 Ch ch ch changes.
2019-09-04 update for latest kicad
2019-09-04 hardware updates: fix input voltage, cnc tweaks (#2)
    * Ch ch ch changes.
    * update for latest kicad
2019-09-08 checkpoint before removing board
2019-09-09 redesign board, additional buttons/i2c header
2019-09-09 fix 5v for i2c header
2019-09-12 voltage regulator footprint
2019-10-05 board updates for prototype
2019-10-05 New Prototype Board (#3)
    * checkpoint before removing board
    * redesign board, additional buttons/i2c header
    * fix 5v for i2c header
    * voltage regulator footprint
    * board updates for prototype
2019-10-06 led strip holders
2019-10-06 duct/led clip fixes
2019-10-07 duct/flat adapter changes
